Commit message: Update rov.urdf

File: src/rov_visualize/urdf/rov.urdf (robot description, URDF)
Before this commit: robot rov, 1 links, 0 joints
Links:
- removed link imu_link
- added link base_link; visual box size=1.8 0.6 0.2
